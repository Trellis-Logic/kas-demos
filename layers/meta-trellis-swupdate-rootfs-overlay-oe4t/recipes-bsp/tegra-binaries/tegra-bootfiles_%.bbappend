DEPENDS += "custom-flash-layout"

PARTITION_FILE_EXTERNAL = "${STAGING_DATADIR}/custom-flash-layout/external-flash.xml"
